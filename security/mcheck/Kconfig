## security/mcheck/Kconfig
```kconfig
config SECURITY_MCHECK_LSM
	bool "Enable security checks on memory mappings"
	depends on SECURITY
```
